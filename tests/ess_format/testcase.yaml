## tests/ess_format/testcase.yaml
```yaml
tests:
  app.ess_format:
    platform_allow:
      - native_sim
    tags:
      - ess
      - unit
```
